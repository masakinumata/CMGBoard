# Repository masakinumata/CMGBoard

## KiCad design hardware/MainBoard/MainBoard.kicad_pcb

Parts:
A101: RaspberryPi_Pico; RaspberryPi_Pico_Common_Unspecified
B101: Board_1U_60x60
D101: Relay; LED_D3.0mm
D102: STAT; LED_D3.0mm
D103: ERROR; LED_D3.0mm
D104: VPP; LED_D3.0mm
D105: VDD; LED_D3.0mm
J101: Servo; JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal
J102: Relay; JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal
J103: MotorDriver; JST_XA_S05B-XASK-1_1x05_P2.50mm_Horizontal
J104: MPU9250; PinSocket_1x10_P2.54mm_Vertical
J105: PicoBATT+; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
J106: Tachometer; JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal
J202: Stop; JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical
R101, R102, R103, R104, R105: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R205: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
SW101: Reset; SW_PUSH_6mm
SW102: SW_Pico; SW_Slide_SPDT_Angled_CK_OS102011MA1Q
SW103: SW_BATT; SW_Slide_SPDT_Angled_CK_OS102011MA1Q

Connections:
/ADO: J104.7
/CLK: A101.24 (GPIO18); also elsewhere on the board
/CS: A101.22 (GPIO17); also elsewhere on the board
/ECL: J104.6
/EDA: J104.5
/ERROR: A101.10 (GPIO7), D103.2 (A)
/FSYNC: J104.10
/IN1: A101.15 (GPIO11), J103.1
/IN2: A101.16 (GPIO12), J103.2
/IN3: A101.17 (GPIO13), J103.3
/IN4: A101.19 (GPIO14), J103.4
/INT: J104.8
/MISO: A101.21 (GPIO16); also elsewhere on the board
/MOSI: A101.25 (GPIO19); also elsewhere on the board
/NCS: J104.9
/OUT1: A101.26 (GPIO20), J106.2
/OUT2: A101.27 (GPIO21), J106.1
/Relay_S: A101.20 (GPIO15), D101.2 (A), J102.1
/SCL: A101.7 (GPIO5), J104.3
/SDA: A101.6 (GPIO4), J104.4
/STAT: A101.9 (GPIO6), D102.2 (A)
/Servo_S: A101.14 (GPIO10), J101.1
GND: A101.3 (GND), A101.8 (GND), A101.13 (GND), A101.18 (GND), A101.23 (GND), A101.28 (GND), A101.38 (GND), B101.GND (GND_GND), J101.3, J102.3, J103.5, J104.2, J105.2, J106.3, R101.1, R102.1, R103.2, R104.2, R105.2, R205.2, SW101.1, SW102.2 (B); also elsewhere on the board
unnamed: A101.37 (3V3_EN), SW102.3 (C)
unnamed: A101.2 (GPIO1), J202.1, R205.1
unnamed: A101.30 (RUN), SW101.2
unnamed: A101.39 (VSYS), SW103.2 (B)
unnamed: D101.1 (K), R101.2
unnamed: D102.1 (K), R102.2
unnamed: D103.1 (K), R103.1
unnamed: D104.2 (A), J105.1, SW103.1 (A)
unnamed: D104.1 (K), R104.1
unnamed: D105.1 (K), R105.1
VDD: A101.36 (3V3), D105.2 (A), J102.2, J104.1, J106.4, J202.2; also elsewhere on the board

Notes on the sheet:
GPIO 16: そのまま（MISO/RX） GPIO 17: CLK → CS に変更 GPIO 18: MOSI → CLK に変更 GPIO 19: CS → MOSI に変更

Parts:
C201, C202: 10uF; C_Disc_D4.7mm_W2.5mm_P5.00mm
C203: 0.1uF; C_Disc_D3.0mm_W1.6mm_P2.50mm
J201: Micro_SD_Card; microSD_HC_Hirose_DM3AT-SF-PEJM5
R201, R202, R203, R204: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal

Connections:
/CLK: J201.5 (CLK); also elsewhere on the board
/CS: J201.2 (DAT3/CD), R203.2; also elsewhere on the board
/MISO: J201.7 (DAT0), R202.2; also elsewhere on the board
/MOSI: J201.3 (CMD); also elsewhere on the board
GND: C201.1, C202.1, C203.1, J201.6 (VSS), J201.10 (DET_A), J201.11 (SHIELD); also elsewhere on the board
unnamed: J201.8 (DAT1), R201.2
unnamed: J201.1 (DAT2), R204.2
VDD: C201.2, C202.2, C203.2, J201.4 (VDD), R201.1, R202.1, R203.1, R204.1; also elsewhere on the board

Board: 2 copper layers, 50.0 x 80.0 mm, 31 parts (0 on the bottom side), 30 nets.

File hardware/MainBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
,,1,,
A101,RaspberryPi_Pico_Common_Unspecified,1,RaspberryPi_Pico,
B101,Board_1U_60x60,1,~,
"C201, C202",C_Disc_D4.7mm_W2.5mm_P5.00mm,2,10uF,
C203,C_Disc_D3.0mm_W1.6mm_P2.50mm,1,0.1,
D101,LED_D3.0mm,1,Relay,
D102,LED_D3.0mm,1,STAT,
D103,LED_D3.0mm,1,ERROR,
D104,LED_D3.0mm,1,VPP,
D105,LED_D3.0mm,1,VDD,
J101,JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal,1,Servo,
J102,JST_XA_S03B-XASK-1_1x03_P2.50mm_Horizontal,1,Relay,
J103,JST_XA_S05B-XASK-1_1x05_P2.50mm_Horizontal,1,MotorDriver,
J104,PinSocket_1x10_P2.54mm_Vertical,1,MPU9250,
J105,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,PicoBATT+,
J106,JST_XA_S04B-XASK-1_1x04_P2.50mm_Horizontal,1,Tachometer,
J201,microSD_HC_Hirose_DM3AT-SF-PEJM5,1,Micro_SD_Card,
J202,JST_PH_B2B-PH-K_1x02_P2.00mm_Vertical,1,Stop,
"R101, R102, R103, R104, R105",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,5,1k,
"R201, R202, R203, R205",R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,4,10k,
R204,R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal,1,All 10k,
SW101,SW_PUSH_6mm,1,Reset,
SW102,SW_Slide_SPDT_Angled_CK_OS102011MA1Q,1,SW_Pico,
SW103,SW_Slide_SPDT_Angled_CK_OS102011MA1Q,1,SW_BATT,

## KiCad design hardware/BMMBMIEvalBoard/BMMBMIEvalBoard.kicad_pcb

Parts:
C101, C103, C106, C108: 0.1uF; C_0402_1005Metric; LCSC C1525
C102, C104, C107, C109, C110, C111: 10uF; C_0603_1608Metric; LCSC C96446
C105: 2.2uF; C_0603_1608Metric; LCSC C23630
D101: PWR; LED_0805_2012Metric; LCSC C2297
J101: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
PULLUP101: SW_DPST_x2; PinHeader_1x02_P2.54mm_Vertical
R101, R102, R103: 4.7k; R_0402_1005Metric
U101: BMM350; BGA9_BMM350_BOS; LCSC C17225907
U102: BMI323; BMI323_BOS; LCSC C5368700
U103: XC6206PxxxMR; SOT-23-3; LCSC C21659

Connections:
/1V8: C101.2, C102.2, C111.1, U101.C1 (VDD), U103.2 (VO)
/3V3: C103.1, C104.1, C106.1, C107.1, C108.1, C109.1, C110.1, D101.2 (A), J101.1, PULLUP101.2 (B), U101.B3 (VDDIO), U102.5 (VDDIO), U102.8 (VDD), U102.12 (CSB), U103.3 (VI); also elsewhere on the board
/INT_IMU1: J101.5, U102.4 (INT1)
/INT_IMU2: J101.6, U102.9 (INT2)
/INT_MAG: J101.7, U101.A1 (INT)
/SCL: J101.3, R102.2, U101.A3 (SCK), U102.13 (SCX)
/SDA: J101.4, R101.2, U101.A2 (SDA), U102.14 (SDX)
GND: C101.1, C102.1, C103.2, C104.2, C105.1, C106.2, C107.2, C108.2, C109.2, C110.2, C111.2, J101.2, R103.2, U101.B1 (GND), U101.B2 (ADSEL), U101.C3 (BYPASS), U102.1 (SDO), U102.6 (GNDIO), U102.7 (GND), U103.1 (GND)
unnamed: D101.1 (K), R103.1
unnamed 9: PULLUP101.1 (A), R101.1, R102.1; also elsewhere on the board
unnamed: C105.2, U101.C2 (CRST)

Board: 2 copper layers, 25.0 x 18.0 mm, 20 parts (0 on the bottom side), 11 nets.

Other parts of the board:
PULLUP: SW_DPST_x2; PinHeader_1x02_P2.54mm_Vertical

Their connections:
/3V3: PULLUP.2 (B); also elsewhere on the board
unnamed 9: PULLUP.1 (A); also elsewhere on the board

File hardware/BMMBMIEvalBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C101, C103, C106, C108",0402,4,0.1uF,
"C102, C104, C107, C109, C110, C111",0603,6,10uF,
C105,0603,1,2.2uF,
D101,0805,1,PWR,
J101,PinHeader_1x07_P2.54mm_Vertical,1,Conn_01x07,
PULLUP,PinHeader_1x02_P2.54mm_Vertical,1,SW_DPST_x2,
"R101, R102, R103",0402,3,4.7k,
U101,BGA9_BMM350_BOS,1,BMM350,
U102,BMI323_BOS,1,BMI323,
U103,SOT-23-3,1,XC6206PxxxMR,

## Commit log

2026-02-21 MainBoardフォルダ作成
2026-02-21 MainBoard作った(未：回転数計、他)
2026-02-22 ちょっと修正
2026-02-22 回転数計を追加。サーボの電源をVCCから引いてみた。
2026-02-22 サーボの電源を未接続にした
2026-02-22 色々つけて、フットプリント割り当てた。
2026-02-22 PCB途中
2026-02-22 ちょっと位置修正と，SDの接続ピン変更
2026-02-22 コネクタ類をまとめた
2026-02-24 PCBで配線少し
2026-02-24 スイッチの配線を変更
2026-02-24 配置をちょっとだけ変更
2026-02-24 線のでこぼこを修正。いくつか0.2mmで接続。
2026-02-25 一応、未配線0になった
2026-02-25 追加し忘れ（未配線0）
2026-02-25 配線をいくつか太くした。もう少し太くできるかも。
2026-02-26 シルクをしてみた
2026-02-26 ちょっとシルク変更してスイッチ追加
2026-02-27 シルク追加してちょっと配線変更
2026-03-14 シルクを少し変更
2026-03-14 もう一回
2026-03-16 BMI323とBMM350の評価基板を発注しようと思ったが高かったので頓挫
2026-03-16 出力できる状態まで
2026-03-19 設計ミス ごめん
2026-03-26 配線ミスを直した
2026-03-26 KiCad10で保存
